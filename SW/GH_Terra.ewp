# IAR project GH_Terra.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\a1\Green_house\GH_Terra\SW\STM8L15x-16x-05x-AL31-L_StdPeriph_Lib_V1.6.1\Libraries\STM8L15x_StdPeriph_Driver\inc; C:\a1\Green_house\GH_Terra\SW
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: GH_Terra.hex
  ILINK.IlinkOutputFile: GH_Terra.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: adc.c lcd.c main.c Main_DSM.c stm8l15x_conf.h stm8l15x_it.c system_time.c usart_debug.c
  group Drivers
    STM8L15x-16x-05x-AL31-L_StdPeriph_Lib_V1.6.1/Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_itc.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c
    STM8L15x-16x-05x-AL31-L_StdPeriph_Lib_V1.6.1/Libraries/STM8L15x_StdPeriph_Driver/inc/: stm8l15x_clk.h
  group Headers
    ./: adc.h configuration.h lcd.h main.h system_time.h usart_debug.h user_typedef.h
    STM8L15x-16x-05x-AL31-L_StdPeriph_Lib_V1.6.1/: iostm8l152c6.h
    STM8L15x-16x-05x-AL31-L_StdPeriph_Lib_V1.6.1/Libraries/STM8L15x_StdPeriph_Driver/inc/: stm8l15x.h
