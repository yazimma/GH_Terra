<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Gh_terra_test_measurment_metod.ewp</path>
  </project>
  <batchBuild/>
</workspace>


